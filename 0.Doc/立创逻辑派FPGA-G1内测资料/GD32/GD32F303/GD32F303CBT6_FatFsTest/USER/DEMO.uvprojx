# Keil uVision project DEMO.uvprojx, settings and files
target DEMO (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303CB GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DEMO +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: ..\USER;..\SYSTEM;..\GD32E23X_FWLIB\Include;..\CORE\Include;..\CORE;..\Library\LED;..\Library\KEY;..\Library\USART;..\Library\LCD;..\Library\SDCard;..\Library\FATFS;..\Library\FATFS\option
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ./: main.c
  group SYSTEM
    ../SYSTEM/: gd32f30x_it.c system_gd32f30x.c systick.c
  group FLIWB
    ../GD32E23X_FWLIB/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group CORE
    ../CORE/: startup_gd32f30x_cl.s
  group Library
    ../Library/LED/: led.c
    ../Library/KEY/: key.c
    ../Library/USART/: usart.c
    ../Library/LCD/: lcd.c lcd_init.c
    ../Library/SDCard/: sdcard.c
  group FatFs
    ../Library/FATFS/: diskio.c ff.c
